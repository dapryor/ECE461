# Keil uVision project RTCS.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RTCS
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Include;.\RTCS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./Source/: timers.c switches.c main.c LEDs.c delay.c ADC.c
  group RTCS
    ./RTCS/: RTCS.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.5.0
