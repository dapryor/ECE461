# Keil uVision project Blinky.uvprojx, settings and files
target ULink -Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Startup
    ./: system_MKL25Z4.c startup_MKL25Z4.s
  group Source Files
    ./: Blinky.c
  group RTX Configuration
    ./: RTX_Config.c
  group Documentation
    ./: Abstract.txt
target ULink -RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
target ULinkPro -Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
target ULinkPro -RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
target CMSIS-DAP -Flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
target CMSIS-DAP -RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
target P&E Micro -Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
target P&E Micro -RAM (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
software components: CMSIS:CORE 4.3.0
