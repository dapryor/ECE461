# Keil uVision project BasicUI.uvprojx, settings and files
target KL25Z Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.9.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: BasicUI
  c flags: Optim=1
  c include: include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Startup
    ./: startup_MKL25Z4.s
    ./src/: system_MKL25Z4.c
  group source
    ./src/: LCD_4bit.c main.c LEDs.c delay.c
  group include
    ./include/: gpio_defs.h lcd_4bit.h
software components: CMSIS:CORE 4.3.0
