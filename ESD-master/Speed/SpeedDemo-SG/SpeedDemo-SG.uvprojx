# Keil uVision project SpeedDemo-SG.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.12.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SpeedDemo-SG
  AfterMake: C:\Users\Alex\Documents\Teaching\ESD\2017-Spring\Code\Speed\SpeedDemo-SG\Scripts\update_regions_MDK.bat
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c misc: --fpmode=fast
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source
    ./Source/: sincos.c timers.c CMAN_coords.c delay.c geometry.c LEDs.c main.c profile.c region.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.5.0
