# Keil uVision project Project_3_Base.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.13.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project_3_Base
  AfterMake: C:\Users\David\Documents\ECE461\project3_test\ESD-master\Speed\Project_3_Base\Scripts\update_regions_MDK.bat
  AfterMake: C:\Users\David\Documents\ECE461\project3_test\ESD-master\Speed\Project_3_Base\Scripts\find_sizes.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM0PLUS
  c misc: --fpmode=fast; C:\Keil\ARM\CMSIS\Lib\ARM\arm_cortexM0I_math.lib
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./Source/: delay.c Drift_Calculation.c LEDs.c main.c profile.c queue.c region.c timers.c UART.c trig_approx.c
software components: CMSIS:CORE 5.0.1, Device:Startup 2.5.0
